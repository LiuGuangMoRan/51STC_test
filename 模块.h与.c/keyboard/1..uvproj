# Keil uVision project 1..uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1.
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Keyboard.c Keyboard.h main.c
    ../../中转/: Delay.c Delay.h
